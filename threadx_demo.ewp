# IAR project threadx_demo.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; DATA_SECTION_IS_CACHEABLE=1; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; CMSIS; azure-rtos/config; azure-rtos/threadx/common/inc; azure-rtos/threadx/ports/cortex_m7/iar/inc; component/lists; component/serial_manager; component/uart; device; drivers; utilities; xip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA; TX_ENABLE_FPU_SUPPORT=1
  ILINK.IlinkOutputFile: threadx_demo.out
  ILINK.IlinkIcfFile: MIMXRT1052/iar/MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; DATA_SECTION_IS_CACHEABLE=1; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052/iar/MIMXRT1052xxxxx_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; DATA_SECTION_IS_CACHEABLE=1; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA; TX_ENABLE_FPU_SUPPORT=1
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; DATA_SECTION_IS_CACHEABLE=1; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMXRT1052/iar/MIMXRT1052xxxxx_flexspi_nor.icf
  group azure-rtos/binary/threadx/cortex_m7/iar
    azure-rtos/binary/threadx/cortex_m7/iar/: libthreadx.a
  group azure-rtos/config
    azure-rtos/config/: tx_user.h
  group azure-rtos/threadx
    azure-rtos/threadx/: LICENSE.txt LICENSED-HARDWARE.txt
  group azure-rtos/threadx/common/inc
    azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/common
    azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group azure-rtos/threadx/ports/cortex_m7/iar/inc
    azure-rtos/threadx/ports/cortex_m7/iar/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/iar/src
    azure-rtos/threadx/ports/cortex_m7/iar/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cachel1_armv7.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group evkbimxrt1050
    evkbimxrt1050/: evkbimxrt1050.mac
  group MIMXRT1052/iar
    MIMXRT1052/iar/: MIMXRT1052xxxxx_flexspi_nor.icf MIMXRT1052xxxxx_ram.icf
  group source
    source/: threadx_demo.c
  group startup
    startup/: startup_MIMXRT1052.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group xip
    xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
